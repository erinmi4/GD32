# Keil uVision project STM32F407.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Firmware\CMSIS\Include;..\Firmware\CMSIS\Device\ST\STM32F4xx\Include;..\Firmware\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Middleware\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c systick.c
  group CMSIS
    ../Firmware/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
    ../Firmware/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Firmware
    ../Firmware/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_usart.c
  group Middleware
    ../Middleware/usart/: Usart0.c
