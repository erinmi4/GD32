# Keil uVision project GD32F470.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F470 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\User;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Hardware;..\MiddleWare;..\MiddleWare\USART;..\MiddleWare\EXTI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_exti.c gd32f4xx_syscfg.c
  group Hardware
    ../Hardware/: batteray.c batteray.h key.c key.h
  group Doc
    ../Doc/: readme.txt
  group MiddleWare
    ../MiddleWare/USART/: Usart0.c Usart0.h
    ../MiddleWare/EXTI/: EXTI0.c EXTI0.h
